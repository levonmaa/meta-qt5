require qtbase.inc
require qt5-${PV}.inc


PR = "r0"