require qtbase.inc
require qt5-4.999+git.inc

PR = "${INC_PR}.0"

#SRCREV = "f7d99ad50f11ee7c263d4c2bdbe024355a1ab3e9"
SRCREV = "b9321a1a5f1b255e5e5860edb42c63a4e4da6804"